# Keil uVision project project.uvprojx, settings and files
target rtthread-SCM620 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: .;..\..\include;applications;.;board;libraries\drivers;libraries\drivers\lib;libraries\drivers\cmsis;libraries\startup;libraries\startup\cmsis\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include\drivers;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\drivers\include\drivers;..\..\components\net\lwip-2.1.0\src\include;..\..\components\net\netdev\include;..\..\components\net\lwip-2.1.0\src;..\..\components\net\lwip-2.1.0\src\arch\include;..\..\components\utilities\ulog;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\uffs;..\..\components\dfs\filesystems\uffs\src\inc;.\applications
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: uart7.c uart0.c
  group Board
    board/: board.c
    ../../components/drivers/spi/: spi_flash_w25qxx.c
    ../../components/drivers/i2c/: fm24clxx.c
    ./board/: drv_gpio.c drv_i2c.c drv_pwm.c drv_rtc.c drv_spi.c drv_timer.c drv_uart.c drv_eth.c drv_wdt.c misc.c drv_nand.c
  group Libraries
    ./libraries/startup/arm/: startup_SCM62X.s
    ./libraries/drivers/lib/: SCM62X_7816.c SCM62X_ADC.c SCM62X_AES.c SCM62X_CAN.c SCM62X_CLK.c SCM62X_CRC.c SCM62X_DMA.c SCM62X_FLASH.c SCM62X_GPIO.c SCM62X_I2C.c SCM62X_IOCTRL.c SCM62X_NFC.c SCM62X_PWM.c SCM62X_RTC.c SCM62X_SCU.c SCM62X_SM4.c SCM62X_SPI.c SCM62X_TIMER.c SCM62X_UART.c SCM62X_WDT.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c rt_drv_pwm.c adc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/watchdog/: watchdog.c
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/drivers/mtd/: mtd_nand.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
